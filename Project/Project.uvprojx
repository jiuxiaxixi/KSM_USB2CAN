# Keil uVision project Project.uvprojx, settings and files
target USBTransmitTest (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 1.54B.1 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: ..\Source\USB;..\Source;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32_USB_Device_Library\Core\inc;..\Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\Libraries\TM_library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USB Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd_int.c usb_dcd.c
    ../Source/USB/: usb_bsp.c
  group USB Device
    ../Source/USB/: usbd_usr.c usbd_desc.c
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../Source/: main.c stm32fxxx_it.c delay.c usart.c can.c coder.c MicroStepDriver.c MSD_test.c one_dimension_code.c usart_screen.c stmflash.c BUZZER.c notification.c mission.c cooler.c adc.c b3470.c temp_control.c wwdg.c
  group STM32F4XX
    ../Source/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group TIM_Driver
    ../Libraries/TM_library/: tm_stm32f4_dma.c tm_stm32f4_gpio.c tm_stm32f4_usart_dma.c tm_stm32f4_usart.c tm_stm32f4_watchdog.c
